void restartesp() {
  
  if (digitalRead(BTN_SELECT) == LOW) {
    delay(200);
    restartDevice();
  }

  
  if (digitalRead(BTN_BACK) == LOW) {
    delay(200);
    drawCancelledMessage();
    while (1); 
  }
}

void drawConfirmationUI() {
  static const unsigned char image_Warning_1_bits[] U8X8_PROGMEM = {0x80,0x00,0xc0,0x01,0xe0,0x01,0x60,0x03,0x70,0x07,0x78,0x07,0x78,0x0f,0x7c,0x1f,0x7e,0x1f,0xfe,0x3f,0x7f,0x7f,0xff,0x3f};
  static const unsigned char image_WarningDolphin_bits[] U8X8_PROGMEM = {0x00,0x00,0x00,0x00,0x08,0x02,0x00,0x00,0x00,0x00,0x08,0x02,0x00,0x00,0xff,0x07,0x10,0x02,0x00,0xc0,0x00,0x18,0x10,0x02,0x00,0x30,0x00,0x60,0x20,0x02,0x00,0x08,0x00,0x80,0x20,0x02,0x00,0x04,0x00,0x00,0x01,0x00,0x00,0x02,0x00,0x00,0x42,0x02,0x00,0x01,0x00,0x00,0x02,0x00,0x00,0x01,0x00,0x00,0x04,0x00,0x80,0x00,0x0f,0x00,0x84,0x07,0x80,0x80,0x10,0x00,0x68,0x08,0x40,0x40,0x2f,0x00,0x18,0x10,0x40,0xa0,0x5b,0x00,0x06,0x10,0x40,0xa0,0x53,0x80,0x01,0x1e,0x40,0xa0,0x5f,0x60,0x80,0x0f,0x20,0xa0,0x5f,0x00,0xc0,0x07,0x20,0x40,0x2f,0x00,0xf0,0x03,0x20,0x80,0x3e,0x00,0xf8,0x01,0x20,0x00,0x41,0x00,0xfc,0x00,0x20,0x80,0x00,0x00,0x7e,0x00,0x20,0x00,0x00,0x00,0x3f,0x00,0x20,0x00,0x00,0xc0,0xf0,0x0f,0x20,0xc0,0x00,0x30,0xc0,0x13,0x20,0x20,0x01,0xff,0x3f,0x10,0x30,0x20,0x01,0x00,0x00,0x10,0x30,0x20,0x01,0x00,0x00,0x08,0x38,0x20,0x01,0x00,0x00,0x06,0x18,0x1e,0x01,0x00,0xc0,0x01,0x1c,0x21,0x01,0xe0,0x3f,0x00,0x9c,0xc0,0x01,0x80,0x1f,0x00,0x8e,0x40,0x02,0x00,0x10,0x00,0x8e,0x42,0x02,0x00,0x10,0x00,0x8f,0x42,0x02,0x00,0x10,0x00,0x87,0x3c,0x02,0x00,0x10,0x00,0x47,0x1c,0x01,0x00,0x10,0x00,0x47,0x80,0x00,0x00,0x10,0x00,0x23,0x40,0x00,0x00,0x20,0x00,0x23,0x40,0x00,0x00,0x20,0x00,0x13,0x40,0x00,0x00,0x20,0x00,0x11,0x40,0x00,0x00,0x20,0x00,0x09,0x40,0x00,0x00,0x20,0x00};


    u8g2.clearBuffer();

    u8g2.setFontMode(1);
    u8g2.setBitmapMode(1);

    // WarningDolphin
    u8g2.drawXBMP(2, 22, 45, 42, image_WarningDolphin_bits);

    // Text
    u8g2.setFont(u8g2_font_haxrcorp4089_tr);
    u8g2.drawStr(59, 23, "are you sure");
    u8g2.drawStr(52, 33, "you want restart");
    u8g2.drawStr(68, 43, "device?!");

    // Warning icon
    u8g2.drawXBMP(75, 3, 15, 12, image_Warning_1_bits);

    // YES button
    u8g2.drawStr(73, 59, "YES");
    u8g2.drawRFrame(69, 49, 26, 13, 3);

    u8g2.sendBuffer();
}

void drawCancelledMessage() {
  u8g2.clearBuffer();
  u8g2.setFont(u8g2_font_6x13_tr);
  u8g2.drawStr(30, 30, "Cancelled!");
  u8g2.sendBuffer();
}

void restartDevice() {
  u8g2.clearBuffer();
  u8g2.setFont(u8g2_font_6x13_tr);
  u8g2.drawStr(30, 30, "Restarting...");
  u8g2.sendBuffer();
  delay(1000);
  ESP.restart();
}
